options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ntsc_hackrf
    output_language: python
  states: {}

blocks:
- name: FM_ampl
  id: variable_qtgui_range
  parameters:
    label: FM amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.11'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: int(48000)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 512000000+1250000
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 107e6
  states: {state: disabled}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    start: '0'
    step: '2400'
    stop: 5*audio_rate
    value: '0'
    widget: slider
  states: {}
- name: delay_vid
  id: variable_qtgui_range
  parameters:
    label: delay_vid
    start: '0'
    step: 5*samp_rate/100
    stop: 5*samp_rate
    value: '0'
    widget: slider
  states: {}
- name: digital_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '47'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: samples_per_line * 60 * .999 * 525 / 2
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: '772'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: TX Frequency
    start: 100e6
    step: '6'
    stop: 700e6
    value: 205.25e6
    widget: slider
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '.1'
    freq: '4500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 25e3
    quad_rate: 10*audio_rate
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 4e6
    low_cutoff_freq: '-2475000 + 1725000'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '500000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: int(delay_vid)
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\conno\Downloads\test.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: digital_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: FM_ampl
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\conno\Downloads\phantom_limb.wav
    repeat: 'True'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: tx_freq
    freq_span: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-4.5e6'
    decim: '1'
    samp_rate: 12.15e6
    taps: '1'
    type: ccc
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: tx_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: 10*audio_rate
    interp: int(12.15e6)
    taps: ''
    type: ccc
  states: {}
- name: zero
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', analog_wfm_tx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0_0, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_delay_0, '0', analog_wfm_tx_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_delay_1, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_wavfile_source_0, '0', blocks_delay_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [zero, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
