options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: file_atsc_tx
    output_language: python
  states: {}

blocks:
- name: BB_gain
  id: variable_qtgui_range
  parameters:
    label: BBG
    start: '0'
    step: '47'
    stop: '47'
    value: '0'
  states: {}
- name: IF_gain
  id: variable_qtgui_range
  parameters:
    label: IFG
    start: '0'
    step: '47'
    stop: '47'
    value: '0'
  states: {}
- name: RF_gain
  id: variable_qtgui_range
  parameters:
    label: RFG
    start: '0'
    step: '47'
    stop: '47'
    value: '0'
  states: {}
- name: center
  id: variable_qtgui_range
  parameters:
    label: center
    start: 88e6
    step: '612'
    stop: 700e6
    value: 207e6
  states: {}
- name: pilot_freq
  id: variable
  parameters:
    value: '309441'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 4500000.0 / 286 * 684
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '-3000000+pilot_freq'
    offset: '0'
    phase: '0'
    samp_rate: symbol_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\conno\Downloads\test_trans.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '832'
    n: '1024'
    offset: '4'
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: symbol_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: dtv_atsc_field_sync_mux_0
  id: dtv_atsc_field_sync_mux
  parameters: {}
  states: {}
- name: dtv_atsc_interleaver_0
  id: dtv_atsc_interleaver
  parameters: {}
  states: {}
- name: dtv_atsc_pad_0
  id: dtv_atsc_pad
  parameters: {}
  states: {}
- name: dtv_atsc_randomizer_0
  id: dtv_atsc_randomizer
  parameters: {}
  states: {}
- name: dtv_atsc_rs_encoder_0
  id: dtv_atsc_rs_encoder
  parameters: {}
  states: {}
- name: dtv_atsc_trellis_encoder_0
  id: dtv_atsc_trellis_encoder
  parameters: {}
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_8VSB
    interpolation: INTERPOLATION_OFF
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: '2'
    taps: firdes.root_raised_cosine(0.1, symbol_rate, symbol_rate/2, 0.1152, 100)
    type: ccc
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center
    freq_span: symbol_rate
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: BB_gain
    clock_source0: external
    freq0: center
    gain0: RF_gain
    if_gain0: IF_gain
    sample_rate: symbol_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(8e6)
    interp: int(symbol_rate)
    taps: '1'
    type: ccc
  states: {state: bypassed}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', dtv_atsc_pad_0, '0']
- [blocks_keep_m_in_n_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [blocks_multiply_xx_0, '0', fft_filter_xxx_0, '0']
- [blocks_throttle_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_keep_m_in_n_0, '0']
- [dtv_atsc_field_sync_mux_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_atsc_interleaver_0, '0', dtv_atsc_trellis_encoder_0, '0']
- [dtv_atsc_pad_0, '0', dtv_atsc_randomizer_0, '0']
- [dtv_atsc_randomizer_0, '0', dtv_atsc_rs_encoder_0, '0']
- [dtv_atsc_rs_encoder_0, '0', dtv_atsc_interleaver_0, '0']
- [dtv_atsc_trellis_encoder_0, '0', dtv_atsc_field_sync_mux_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', blocks_multiply_xx_0, '1']
- [fft_filter_xxx_0, '0', osmosdr_sink_0, '0']
- [fft_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
